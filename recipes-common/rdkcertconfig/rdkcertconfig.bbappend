DEPENDS_remove = "mountutils"
DEPENDS_remove = "ssacpc"

DEPENDS_append = " rdk-logger"

EXTRA_OECONF_remove = "--enable-cspcrdkconfig"
