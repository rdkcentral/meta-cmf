SRC_URI_remove = "git://github.com/rdkcentral/common_utilities.git;protocol=git"
SRC_URI += "git://github.com/rdkcentral/common_utilities.git;protocol=git;nobranch=1"
